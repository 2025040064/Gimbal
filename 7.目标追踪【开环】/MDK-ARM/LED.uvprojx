# Keil uVision project LED.uvprojx, settings and files
target LED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: LED +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../HARDWARE/OLED;..\HARDWARE\MORTOR;..\HARDWARE\K230;..\HARDWARE\K230;..\HARDWARE\ADC;..\HARDWARE\MPU6050;..\HARDWARE\STABILIZER;..\HARDWARE\DWT_DELAY;..\HARDWARE\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    D:/(!解压缩密码是VCC)(下载winRAR解压)STM32小车相关资料V3.3.0_3(更新openmv 电磁 添加FreeRTOS 更新论文) (20250330)/STM32小车相关资料V3.3.0/01程序资料/MyCode_V3.3.0/04_LED/LED/Core/Inc/: usart.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/MORTOR/: motor.c motor.h
    ../HARDWARE/K230/: k230.c k230.h
    ../HARDWARE/ADC/: adc.c adc.h
    ../HARDWARE/MPU6050/: mpu6050.c mpu6050.h
    ../HARDWARE/STABILIZER/: stabilizer.c stabilizer.h
    ../HARDWARE/DWT_DELAY/: dwt_delay.c dwt_delay.h
    ../HARDWARE/APP/: app.c app.h
software components: CMSIS:CORE 4.3.0
